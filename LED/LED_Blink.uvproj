# Keil uVision project LED_Blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LED_Blink +hex
  c flags: SizeSpeed=1
  c include: ..\include;..\include
  group Source Group 1
    ./: STARTUP.A51
    ../bin/: main.c
    ../src/: delay.c
